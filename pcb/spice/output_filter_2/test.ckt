**************************************************************
*  Electronic circuit simulation file generated by gSpiceUI  *
*             Version 0.9.98 Alpha (14/10/2009)              *
**************************************************************

* test

* Component Definitions
C1 0 OUT 100n
L1 0 OUT 22n
* Signal source (V1 0 OUT AC 1.0)
V1 0 OUT GENERATOR(1) AC 1.00

* GNU-Cap Simulation Commands
.OPTIONS NOPAGE
.PRINT AC VDB(OUT)
.AC 1.00 100.00Meg DE 10 TE 27.00 BASIC

.END
